* This is a comment.

R1 0 1 30
R2 1 2 10
VDD 2 0 DC 3
I 1 0 DC 5
